options:
  parameters:
    author: srs
    copyright: srs 2021
    description: multitone waveform generator
    generate_options: qt_gui
    id: mutlitone_gen
    output_language: python
    title: multitone_gen
  states: {}

blocks:
- name: freq_spacing
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,1,1,1]'
    label: Spacing of Tones
    orient: Qt.Horizontal
    rangeType: int
    start: '25000'
    step: '25000'
    stop: '10000000'
    value: '1000000'
  states: {}
- name: jam_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: '[0,2, 1,1]'
    label: JAM
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: num_tones
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Number of Tones
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: sdr_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,2,1,1]'
    label: SDR frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '60000000'
    step: '10000'
    stop: '6000000000'
    value: '136050000'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Tone Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '100'
    step: '100'
    stop: '10000000'
    value: '100'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,0,1,1]'
    label: 'Select Waveform '
    label0: Square
    label1: Sawtooth
    label2: Sine
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq+freq_spacing/2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Time Sync block
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not(jam_button)
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from random import seed
      from random import random
      from gnuradio import gr
      from scipy import signal
      from scipy.signal import find_peaks, peak_prominences
      import logging, sys

      #waveform = np.uint32
      #samp_rate = np.uint32
      #ctr_freq = np.uint32
      #num_tones = np.uint32
      #freq_spacing = np.uint32

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, waveform=0, samp_rate=10000000, ctr_freq=0, num_tones=3, freq_spacing=1000000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.waveform = waveform
              self.samp_rate = samp_rate
              self.ctr_freq=ctr_freq
              self.num_tones=num_tones
              self.freq_spacing = freq_spacing
              

          	    
          def work(self, input_items, output_items):

              def signaltonoise(s, axis=0, ddof=0): 
               a=np.asanyarray(s)
               m=a.mean(axis)
               sd=a.std(axis=axis, ddof=ddof)
               
              # implement random seed for phase offset
              seed(1)
              num_samples=np.uint32
              num_samples= input_items[0].size
              #logging.debug(print(num_samples))
      	
      	#Create start and stop frequency
              if self.num_tones > 1:
              	spread     =  self.freq_spacing*self.num_tones
              	start_freq =  0 - spread/2
              	end_freq   =  0 + spread/2
              	ctr_freqs  =  np.linspace(start_freq, end_freq,self.num_tones)
              else:
              	ctr_freqs  = (self.ctr_freq, self.ctr_freq)
             
              # Create empty vectors	
              temp_data = np.zeros((1,num_samples),dtype=np.complex64)
              data_new = np.zeros((1,num_samples),dtype=np.complex64)
              mt = np.zeros((1,num_samples),dtype=np.complex64)
         	# Create time vector
              t = np.linspace(0,num_samples/self.samp_rate,num_samples)
              
              # Add the waveforms at spaced frequencies to make a multitone
              for n in range(len(ctr_freqs)):
              	if   self.waveform == 0:
              		data_new = signal.square(2*np.pi*(ctr_freqs[n]+self.ctr_freq)*t*random()) 
              	elif self.waveform == 1:
              		data_new = signal.sawtooth(2 * np.pi * ctr_freqs[n] * t )
              	else:
              		data_new = np.sin(2 * np.pi * ctr_freqs[n] * t )
              	 
              	temp_data = temp_data + data_new
              	#signal.chirp(t, start_freq, num_samples/self.samp_rate, end_freq, method='linear')
              	
              	
              mt = np.divide(temp_data[0:2],np.ndarray.max(abs(temp_data[0:2])))	
              output_items[0][:] = temp_data[0:2]
              #print (mt[0:2][0])
              return len(output_items[0])
    ctr_freq: '10000000'
    freq_spacing: freq_spacing
    num_tones: num_tones
    samp_rate: samp_rate
    waveform: waveform
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: sdr_freq
    samplerate: samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: sdr_freq
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '(num_tones*freq_spacing) '
    color1: '"yellow"'
    color2: '"magenta"'
    fc: tone_freq
    fftsize: '2048'
    gui_hint: '[2,0,2,3]'
    label1: rx_data
    label2: tx_data
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0_0_0_0, '0', epy_block_0, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_mute_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_0, '0', blocks_mute_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
