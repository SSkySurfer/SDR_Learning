options:
  parameters:
    author: SRS, 2020
    description: Pluto SDR FM transceiver
    generate_options: qt_gui
    id: NBFM_transceiver
    output_language: python
    title: NBFM_transceiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,2,1,1]'
    label: rx_tx_offset
    label0: 5Mhz
    label1: 600kHz
    num_opts: '2'
    option0: '5000000'
    option1: '600000'
    type: real
    value: '5000000'
  states: {}
- name: rx_aud
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,1,1,1]'
    label: rx_audio_gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.300'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,2]'
    label: rx_freq
    orient: Qt.Horizontal
    start: '88000000'
    step: '25000'
    stop: '470000000'
    value: '446578300'
  states: {}
- name: rx_freq_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3,1,1,1]'
    label: rx_freq_fine
    orient: Qt.Horizontal
    start: '-10000'
    step: '100'
    stop: '10000'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,1]'
    label: rx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '74'
    value: '55'
  states: {}
- name: rx_tx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,0,1,1]'
    label: rx_tx_pushbutton
    label0: RX
    label1: TX
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {state: disabled}
- name: rx_tx
  id: variable_qtgui_push_button
  parameters:
    comment: PTT Switch
    gui_hint: '[0,0,1,1]'
    label: PTT
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sdr_samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: sdr_sample_rate
    orient: Qt.Horizontal
    start: '520833 '
    step: '100000'
    stop: '61440000'
    value: '1000000'
  states: {}
- name: sqch
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3,0,1,1]'
    label: rx_sqlch
    orient: Qt.Horizontal
    start: '-110'
    step: '1'
    stop: '-30'
    value: '-42'
  states: {}
- name: tx_freq
  id: variable_qtgui_label
  parameters:
    gui_hint: '[1,2,1,1]'
    label: tx_freq
    type: real
    value: rx_freq-offset
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,2,1,1]'
    label: tx_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '1'
  states: {}
- name: Internal_Microphone
  id: audio_source
  parameters:
    comment: Microphone
    samp_rate: '48000'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 12.5e3
    quad_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*fsk_deviation/audio_rate)
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: sdr_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: CTCSS tone when Freq not = 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_aud*(-(rx_tx)+1)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: not rx_tx
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: C:\Users\rswee\OneDrive\Documents\SCHOOL\ECE531\NBFM_rx_test.wav
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Saved File
    file: /home/gnuradio/Documents/Example_Audio/exampleAudio_caution.wav
    repeat: 'True'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_freq
    freq_span: sdr_samp_rate
    gui_hint: '[4,0,6,3]'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '-tx_gain*(rx_tx)'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '0x4000'
    cyclic: 'False'
    frequency: tx_freq
    samplerate: sdr_samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '75000'
    frequency: rx_freq
    gain1: '''slow_attack'''
    manual_gain1: rx_gain*(-rx_tx+1)
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sdr_samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '16000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: sdr_samp_rate
    type: fir_filter_ccf
    width: 48e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '25000'
    fc: rx_freq
    fftsize: '256'
    gui_hint: '[4,0,6,3]'
    plotfreq: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Increases Sample Rate
    decim: audio_rate
    interp: sdr_samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: sdr_samp_rate
    interp: audio_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: sdr_samp_rate
    interp: audio_rate
    taps: ''
    type: ccf
  states: {}

connections:
- [Internal_Microphone, '0', low_pass_filter_1, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_2, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_1, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_multiply_xx_1, '0', analog_nbfm_tx_0, '0']
- [blocks_mute_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_1, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_xx_1, '0']
- [low_pass_filter_2, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_mute_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_1, '0', fosphor_qt_sink_c_0, '0']
- [rational_resampler_xxx_0_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
