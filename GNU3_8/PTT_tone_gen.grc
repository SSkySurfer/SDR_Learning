options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: duty_cycle
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Duty Cycle (%)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '136050000'
  states: {}
- name: freq_vector
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: int
    value: '136050000'
    writeback: None
  states: {}
- name: pri
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: PRI (sec)
    orient: Qt.Horizontal
    start: '2e-6'
    step: '0.5e-6'
    stop: '1'
    value: '1'
  states: {}
- name: pri_tau
  id: variable
  parameters:
    value: round(pri/(1/samp_rate))
  states: {}
- name: pulse_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Pulse Freq (Hz)
    orient: Qt.Horizontal
    start: '10'
    step: '100'
    stop: 20e3
    value: '410'
  states: {}
- name: pulse_spacing
  id: variable
  parameters:
    value: round((pri/pw)*((100-duty_cycle)/100)*(pw_tau))
  states: {}
- name: pulse_vector
  id: variable
  parameters:
    value: '[1]*pw_tau+[0]*(pulse_spacing)'
  states: {}
- name: pw
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1 , 1, 1, 1]'
    label: PW (sec)
    orient: Qt.Horizontal
    start: '1e-6'
    step: '0.5e-6'
    stop: '1'
    value: '1'
  states: {}
- name: pw_tau
  id: variable
  parameters:
    value: round(pw/(1/samp_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: pulse_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: For a pulse limited signal
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: pulse_vector
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate/2
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: freq_vector
    samplerate: samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '35'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: '[2,0,3,3]'
    size: '1024'
    srate: samp_rate/2
    tr_delay: '0.0'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', iio_pluto_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_1, '0']
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
