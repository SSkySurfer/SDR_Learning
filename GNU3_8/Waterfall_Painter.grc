options:
  parameters:
    author: srs
    copyright: srs 2021
    description: Paints pictures on waterfall of rx
    generate_options: qt_gui
    id: Paint_spectrum
    output_language: python
    title: Waterfall_Painter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: '2084000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: /home/gnuradio/Pictures/f16_schem_01.gif
    image_flip: '1'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '2'
    width: '346'
  states: {}

connections:
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
